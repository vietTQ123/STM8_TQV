# IAR project GPIO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: C:\Users\VIETNGU\Documents\EMBEDDED_LAB\STM8\Project\1.STM8S_GPIO; C:\Users\VIETNGU\Documents\EMBEDDED_LAB\STM8\Lib; C:\Users\VIETNGU\Documents\EMBEDDED_LAB\STM8\Lib\inc; C:\Users\VIETNGU\Documents\EMBEDDED_LAB\STM8\Lib\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    ../../Lib/: STM8CONFIG.h stm8s_conf.h stm8s_it.c stm8s_it.h
    ../../Lib/inc/: stm8s.h stm8s_gpio.h
    ../../Lib/src/: stm8s_gpio.c
  group User
    ./: main.c

# IAR project 7SEGMENT_2DIGIT.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: C:\Users\VIETNGU\Documents\EMBEDDED_LAB\STM8\Project\4.STM8S_7SEGMENT_2DIGIT; C:\Users\VIETNGU\Documents\EMBEDDED_LAB\STM8\Lib; C:\Users\VIETNGU\Documents\EMBEDDED_LAB\STM8\Lib\inc; C:\Users\VIETNGU\Documents\EMBEDDED_LAB\STM8\Lib\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 7SEGMENT_2DIGIT.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    ../../Lib/: STM8CONFIG.h stm8s_conf.h stm8s_it.c stm8s_it.h
    ../../Lib/inc/: stm8s.h stm8s_gpio.h
    ../../Lib/src/: stm8s_gpio.c
  group User
    ./: main.c

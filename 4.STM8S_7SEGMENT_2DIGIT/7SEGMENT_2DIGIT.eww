<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\7SEGMENT_2DIGIT.ewp</path>
    </project>
    <batchBuild />
</workspace>

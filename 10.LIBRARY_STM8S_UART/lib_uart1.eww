<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LIBRARY_STM8S_UART.ewp</path>
    </project>
    <batchBuild />
</workspace>

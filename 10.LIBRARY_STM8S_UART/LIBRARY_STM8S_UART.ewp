# IAR project LIBRARY_STM8S_UART.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\..\Lib; ..\..\Lib\inc; ..\..\Lib\src; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LIBRARY_STM8S_UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    ./: lib_uart.c lib_uart.h
    ../../Lib/: STM8CONFIG.h stm8s_conf.h stm8s_it.c stm8s_it.h
    ../../Lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_itc.c stm8s_uart1.c
    ../../Lib/inc/: stm8s_clk.h stm8s_gpio.h stm8s_itc.h stm8s_uart1.h
  group User
    ./: main.c

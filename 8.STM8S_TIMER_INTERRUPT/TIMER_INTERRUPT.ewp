# IAR project TIMER_INTERRUPT.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\Lib; ..\..\Lib\inc; ..\..\Lib\src
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    ../../Lib/: STM8CONFIG.h stm8s_conf.h stm8s_it.c stm8s_it.h
    ../../Lib/inc/: stm8s.h stm8s_clk.h stm8s_gpio.h stm8s_tim1.h stm8s_tim4.h
    ../../Lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_tim4.c
  group User
    ./: main.c
